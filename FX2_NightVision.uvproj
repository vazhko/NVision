# Keil uVision project FX2_NightVision.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB FX2 (CY7C68XXX) Cypress Semiconductor
  cpu: IRAM(0 - 0xFF) XRAM(0 - 0x3FF) CLOCK(48000000) MODDP2
  output: FX2_NightVision +hex
  AfterMake: exe\hex2bix -i -f 0xC2 -o FX2_NightVision.iic .\out\FX2_NightVision.hex
  AfterMake: exe\hex2bix -i -f 0xc0 -p 0x04B4 -v 0x1004 -o .\out\FX2_NightVision.bin
  c flags: Optimize=8 SizeSpeed=1
  c include: lib\
  group Source Group 1
    ./: fw.c dscr.a51 gpif.c readme.txt spi.c main.c
    ./lib/: EZUSB.LIB USBJmpTb.OBJ
